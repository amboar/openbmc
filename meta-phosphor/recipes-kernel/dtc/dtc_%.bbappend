PROVIDES += "libfdt"
