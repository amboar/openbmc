require python-pyflame.inc

SRC_URI = "https://github.com/uber/pyflame/archive/v${PV}.tar.gz"
SRC_URI[md5sum] = "53d5822e5be371303e217a68ea9ea3e5"
SRC_URI[sha256sum] = "03723509c037a994585e81e4a9c6d8e4fed87b486e23edd8d355a7bcc009bf79"
